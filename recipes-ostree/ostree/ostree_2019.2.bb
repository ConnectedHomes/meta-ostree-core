require ostree.inc

SRCREV = "80435e12a7ec055195d2355b60a0882b65d42a94"
