require ostree.inc

SRCREV = "5c1697da78ebf6250a7130b8b9e6cbfbeaa34296"
