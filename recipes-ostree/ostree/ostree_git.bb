require ostree.inc

SRCREV = "${AUTOREV}"

PV .= "+${SRCPV}"

DEFAULT_PREFERENCE = "-1"
